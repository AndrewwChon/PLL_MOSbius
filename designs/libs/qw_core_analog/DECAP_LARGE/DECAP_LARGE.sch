v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 740 -310 800 -310 {lab=vdd}
N 740 -290 800 -290 {lab=vss}
C {libs/qw_core_analog/DECAP_SC/DECAP_SC.sym} 590 -300 0 0 {name=x[1:126]}
C {iopin.sym} 800 -310 0 0 {name=p1 lab=vdd}
C {iopin.sym} 800 -290 0 0 {name=p2 lab=vss}
