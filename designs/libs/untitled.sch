v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {top_level/top_level_scan_20250802/top_level_scan_20250802.sym} 120 -30 0 0 {name=x1}
