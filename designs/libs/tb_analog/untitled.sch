v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {libs/behavioral_models/ro_vco.sym} 20 30 0 0 {}
