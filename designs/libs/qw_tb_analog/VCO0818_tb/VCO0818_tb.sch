v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
