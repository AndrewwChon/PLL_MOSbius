** sch_path: designs/libs/core_analog/scope_in/scope_in.sch
**.subckt scope_in in VSSd
*.iopin in
*.iopin VSSd
R1 in VSSd 1M m=1
C1 in VSSd 20p m=1
**.ends
.end
