v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 510 -560 560 -560 {lab=#net1}
N 630 -640 630 -600 {lab=#net2}
N 680 -560 730 -560 {lab=#net3}
C {VCO_git.sym} 20 50 0 0 {name=X1}
