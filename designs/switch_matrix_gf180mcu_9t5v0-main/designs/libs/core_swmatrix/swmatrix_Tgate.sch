v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 177.5 -20 190 -20 {lab=T2}
N 130 -60 147.5 -60 {lab=control}
N 90 -20 110 -20 {lab=T1}
C {iopin.sym} 90 -20 0 1 {name=p1 lab=T1}
C {iopin.sym} 190 -20 0 0 {name=p2 lab=T2}
C {ipin.sym} 130 -60 0 0 {name=p3 lab=control}
C {noconn.sym} 147.5 -60 0 1 {name=l1}
C {noconn.sym} 110 -20 0 1 {name=l2}
C {noconn.sym} 177.5 -20 0 0 {name=l3}
